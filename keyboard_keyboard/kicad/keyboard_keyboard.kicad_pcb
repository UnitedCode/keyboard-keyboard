# Repository UnitedCode/keyboard-keyboard

File README.md:

# keyboard-keyboard

**Experimental branch:** USB MIDI 2.0 with MIDI 1.0 fallback, simultaneous DIN
output, and a screen routing selector. See [USB MIDI](keyboard_keyboard/code/USB_MIDI.md)
for connections, controls, verification, and remaining physical checks.

A hall-effect MIDI keyboard controller built around the Electrosmith Daisy Seed (STM32H750V). The layout follows the IBM Model M form factor but is tuned to work as a Wicki-Hayden isomorphic musical keyboard. Keys 81–100 are drum pads on MIDI channel 10.

## Hardware

- **MCU:** Electrosmith Daisy Seed Rev4 (STM32H750V)
- **Sensors:** 100x MT9105ET hall-effect sensors across 13 SN74LV4051A analog muxes (AM1–AM13)
- **Pots:** 12 trim potentiometers on AM14–AM15, read as MIDI CC
- **Display:** 128x32 SSD1306 OLED over I2C
- **MIDI:** USART1 at 31250 baud (DIN-5 out, opto-isolated in via 6N138), plus built-in Seed USB MIDI 1.0/2.0

The firmware drives 100 switches across 13 muxes plus 12 pots on AM14–AM15.
Existing boards need the revision-specific checks in [Known Issues](#known-issues).

Full pin mapping and mux architecture: [`keyboard_keyboard/code/HARDWARE.md`](keyboard_keyboard/code/HARDWARE.md)

KiCad schematic: `keyboard_keyboard/kicad/keyboard_keyboard.kicad_sch`

## Firmware

Firmware is in `keyboard_keyboard/code/`, written in Rust using [RTIC](https://rtic.rs/) for the real-time task scheduler.

### Setup

```sh
rustup target add thumbv7em-none-eabihf
rustup component add llvm-tools-preview
cargo install cargo-binutils
# probe-rs / cargo-embed: https://probe.rs/docs/getting-started/installation/
```

### Build and flash

Run these from `keyboard_keyboard/code/`:

```sh
cargo check        # type-check without a connected device
cargo build        # compile for thumbv7em-none-eabihf
cargo embed        # flash to Daisy Seed (reads Embed.toml)
```

RTT logs stream automatically during `cargo embed`. Set `DIAG_LOGGING = true` in `src/main.rs` for verbose per-switch ADC and baseline output.

GDB attach (in a separate terminal after `cargo embed`):

```sh
arm-none-eabi-gdb target/thumbv7em-none-eabihf/debug/app
# in gdb:
target remote :1337
```

### How it works

The `timer_handler` task fires at 1 kHz, scans all 13 muxes × 8 channels, and runs a three-state machine (`Idle → FirstActuated → FullyActuated`) per switch. Velocity uses interpolated crossings from a two-sample measurement filter; note validation retains four-sample smoothing and three-scan confirmation. A configurable three-anchor response maps transit time to MIDI velocity. Pot values are scanned every 10 ms and sent as CC messages. MIDI events queue into a `heapless::spsc::Queue` and are sent by a lower-priority `process_events` task.

Boot calibration averages 64 ADC samples per switch to establish per-key baselines before the timer starts.

The [velocity investigation and Rust simulations](tools/seed-tests/VELOCITY.md)
compare the old algorithm and five alternatives across synthetic press speeds,
sensor spans, magnetic responses, noise and scan jitter. The response defaults
are provisional pending physical key recordings and listening tests.

## Known Issues

**Older fabricated boards:** U1 pins 7/Y7 and 9/Y6 were incorrectly grounded.
The current schematic leaves them explicitly unconnected; the PCB isolates them
from the ground pour and directly connects enable pins 4/5 to ground. The copper
zones are refilled to clear the pot ADC trace. A source-file update does not
repair an existing PCB: inspect the built revision before applying rework.

**Current pin mapping:** U1 pins 4/5 are low, pin 6 is high. Pot ADC input is
Daisy pad 35 (D28/A11); pad 33 is unconnected. Earlier instructions claiming that
the current design needs a pin-5 bridge or pad-33 bodge are obsolete.

**Power and temperature:** 100 Hall sensors are a substantial continuous load.
The hot-room incident still needs rail/current/temperature measurements. A
regulator upgrade has not been validated. See the [hardware reference](keyboard_keyboard/code/HARDWARE.md).

**Firmware timing:** MIDI transmission runs outside the priority-15 event-queue
lock. Full-scan event storage prevents the old 32-key burst limit; queue overload
is logged and sends all-channel All Notes Off to recover lost releases. Actual
firmware verification commands for the stable polling-UART revision are in
[seed-tests](tools/seed-tests/README.md). This branch adds independent output queues
and interrupt-driven DIN TX; its virtual Seed run is blocked by missing model
support. See [USB MIDI verification](keyboard_keyboard/code/USB_MIDI.md#verification).

## Acknowledgements

- Hall-effect keyboard layout based on [peppapighs/HE60](https://github.com/peppapighs/HE60/tree/main)
- Model M physical layout based on [dcpedit/mod-mmm](https://github.com/dcpedit/mod-mmm)

## KiCad design keyboard_keyboard/kicad/keyboard_keyboard.kicad_pcb

Parts (part):
A1: Electrosmith_Daisy_Seed_Rev4; Electrosmith_Daisy_Seed; not fitted
AM1, AM2, AM3, AM4, AM5, AM6, AM7, AM8, AM9, AM10, AM11, AM12, AM13, AM14, AM15: SN74LV4051A; TSSOP-16_4.4x5mm_P0.65mm; LCSC C7793
C1, C3, C5, C7, C9, C11, C13, C15, C17, C19, C21, C23, C25, C27, C29, C31, C33, C35, C37, C39, C41, C43, C45, C47, C49, C51, C53, C55, C57, C59, C61, C63, C65, C67, C69, C71, C73, C75, C77, C79, C81, C83, C85, C87, C89, C91, C93, C95, C97, C99, C101, C103, C105, C107, C109, C111, C113, C115, C117, C119, C121, C123, C125, C127, C129, C131, C133, C135, C137, C139, C140, C141, C142, C143, C144, C145, C146, C147, C148, C149, C150, C151, C161, C162, C163, C165, C167, C169, C171, C173, C175, C177, C179, C181, C183, C185, C187, C189, C191, C193, C195, C197, C199, C201, C203, C205, C207, C209, C211, C213, C215, C217, C219, C221, C223: 100n; C_0402_1005Metric; LCSC C307331
C2, C4, C6, C8, C10, C12, C14, C16, C18, C20, C22, C24, C26, C28, C30, C32, C34, C36, C38, C40, C42, C44, C46, C48, C50, C52, C54, C56, C58, C60, C62, C64, C66, C68, C70, C72, C74, C76, C78, C80, C82, C84, C86, C88, C90, C92, C94, C96, C98, C100, C102, C104, C106, C108, C110, C112, C114, C116, C118, C120, C122, C124, C126, C128, C130, C132, C134, C136, C138, C164, C166, C168, C170, C172, C174, C176, C178, C180, C182, C184, C186, C188, C190, C192, C194, C196, C198, C200, C202, C204, C206, C208, C210, C212, C214, C216, C218, C220, C222, C224: 4.7n; C_0402_1005Metric; LCSC C1548
D1, D2, D3: LED; LED_D3.0mm; not fitted
D13: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal; not fitted
HE1, HE2, HE3, HE4, HE5, HE6, HE7, HE8, HE9, HE10, HE11, HE12, HE13, HE14, HE15, HE16, HE17, HE18, HE19, HE20, HE21, HE22, HE23, HE24, HE25, HE26, HE27, HE28, HE29, HE30, HE31, HE32, HE33, HE34, HE35, HE36, HE37, HE38, HE39, HE40, HE41, HE42, HE43, HE44, HE45, HE46, HE47, HE48, HE49, HE50, HE51, HE52, HE53, HE54, HE55, HE56, HE57, HE58, HE59, HE60, HE61, HE62, HE63, HE64, HE65, HE66, HE67, HE68, HE69, HE70, HE71, HE72, HE73, HE74, HE75, HE76, HE77, HE78, HE79, HE80, HE81, HE82, HE83, HE84, HE85, HE86, HE87, HE88, HE89, HE90, HE91, HE92, HE93, HE94, HE95, HE96, HE97, HE98, HE99, HE100: MT9102ET; SOT-23-3; LCSC C5447698
J1, J2: AudioJack3_Ground; Jack_3.5mm_PJ320E_Horizontal; not fitted
J3: Screen Connector; PinHeader_1x04_P2.54mm_Vertical; not fitted
J4, J5: DIN-5; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; not fitted
J6: Conn_01x04_Socket; Molex_Pico-EZmate_78171-0004_1x04-1MP_P1.20mm_Vertical; not fitted
J7: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical; not fitted
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX31, MX32, MX33, MX34, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX45, MX46, MX47, MX48, MX49, MX50, MX51, MX52, MX53, MX54, MX55, MX56, MX57, MX58, MX60, MX61, MX62, MX63, MX64, MX65, MX66, MX67, MX68, MX69, MX71, MX72, MX73, MX74, MX75, MX76, MX77, MX78, MX79, MX80, MX81, MX82, MX83, MX84, MX85, MX86, MX87, MX88, MX89, MX90, MX91, MX92, MX93, MX94, MX95, MX96, MX97, MX98, MX99, MX100: 1U; MX-1U; not fitted
MX14, MX30, MX43, MX59, MX70: 1.5U; MX-1.5U; not fitted
MX44: 1u; MX-1U; not fitted
R1, R2, R3: R_Small_US; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; not fitted
R4, R5: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal; not fitted
R6: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal; not fitted
R7: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal; not fitted
R8: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal; not fitted
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
Connections (part):
+3.3VA: A1.38 (3V3_D), AM1.16 (VDD), AM2.16 (VDD), AM3.16 (VDD), AM4.16 (VDD), AM5.16 (VDD), AM6.16 (VDD), AM7.16 (VDD), AM8.16 (VDD), AM9.16 (VDD), AM10.16 (VDD), AM11.16 (VDD), AM12.16 (VDD), AM13.16 (VDD), AM14.16 (VDD), AM15.16 (VDD), C1.1, C3.1, C5.1, C7.1, C9.1, C11.1, C13.1, C15.1, C17.1, C19.1, C21.1, C23.1, C25.1, C27.1, C29.1, C31.1, C33.1, C35.1, C37.1, C39.1, C41.1, C43.1, C45.1, C47.1, C49.1, C51.1, C53.1, C55.1, C57.1, C59.1, C61.1, C63.1, C65.1, C67.1, C69.1, C71.1, C73.1, C75.1, C77.1, C79.1, C81.1, C83.1, C85.1, C87.1, C89.1, C91.1, C93.1, C95.1, C97.1, C99.1, C101.1, C103.1, C105.1, C107.1, C109.1, C111.1, C113.1, C115.1, C117.1, C119.1, C121.1, C123.1, C125.1, C127.1, C129.1, C131.1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
Audio_in_1: A1.16 (AUDIO_IN_1), J1.T
Audio_in_2: A1.17 (AUDIO_IN_2), J1.R1
Audio_out_1: A1.18 (AUDIO_OUT_1), J2.T
Audio_out_2: A1.19 (AUDIO_OUT_2), J2.R1
D+: A1.37 (USB_D_+), J6.3, J7.3
D-: A1.36 (USB_D_-), J6.2, J7.2
ENABLE_10: AM10.6 (Inh), U1.15 (~Y0)
ENABLE_11: AM11.6 (Inh), U1.14 (~Y1)
ENABLE_12: AM12.6 (Inh), U1.13 (~Y2)
ENABLE_13: AM13.6 (Inh), U1.12 (~Y3)
ENABLE_14: AM14.6 (Inh), U1.11 (~Y4)
ENABLE_15: AM15.6 (Inh), U1.10 (~Y5)
ENB_A: A1.5 (SD_DATA_0), U1.1 (A0)
ENB_B: A1.4 (SD_DATA_1), U1.2 (A1)
ENB_C: A1.3 (SD_DATA_2), U1.3 (A2)
GND: A1.20 (AGND), A1.40 (DGND), AM1.6 (Inh), AM1.7 (VEE), AM1.8 (VSS), AM2.6 (Inh), AM2.7 (VEE), AM2.8 (VSS), AM3.6 (Inh), AM3.7 (VEE), AM3.8 (VSS), AM4.6 (Inh), AM4.7 (VEE), AM4.8 (VSS), AM5.6 (Inh), AM5.7 (VEE), AM5.8 (VSS), AM6.6 (Inh), AM6.7 (VEE), AM6.8 (VSS), AM7.6 (Inh), AM7.7 (VEE), AM7.8 (VSS), AM8.6 (Inh), AM8.7 (VEE), AM8.8 (VSS), AM8.12 (X3), AM8.13 (X0), AM9.6 (Inh), AM9.7 (VEE), AM9.8 (VSS), AM10.7 (VEE), AM10.8 (VSS), AM10.12 (X3), AM11.7 (VEE), AM11.8 (VSS), AM11.12 (X3), AM12.7 (VEE), AM12.8 (VSS), AM13.7 (VEE), AM13.8 (VSS), AM14.7 (VEE), AM14.8 (VSS), AM15.7 (VEE), AM15.8 (VSS), AM15.12 (X3), AM15.13 (X0), AM15.14 (X1), AM15.15 (X2), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2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
HE1: AM1.1 (X4), C2.1, HE1.2 (OUT)
HE2: AM1.2 (X6), C4.1, HE2.2 (OUT)
HE3: AM1.4 (X7), C6.1, HE3.2 (OUT)
HE4: AM1.5 (X5), C8.1, HE4.2 (OUT)
HE5: AM1.15 (X2), C10.1, HE5.2 (OUT)
HE6: AM1.14 (X1), C12.1, HE6.2 (OUT)
HE7: AM1.13 (X0), C14.1, HE7.2 (OUT)
HE8: AM1.12 (X3), C16.1, HE8.2 (OUT)
HE9: AM2.1 (X4), C18.1, HE9.2 (OUT)
HE10: AM2.2 (X6), C20.1, HE10.2 (OUT)
HE11: AM2.4 (X7), C22.1, HE11.2 (OUT)
HE12: AM2.5 (X5), C24.1, HE12.2 (OUT)
HE13: AM2.15 (X2), C26.1, HE13.2 (OUT)
HE14: AM2.14 (X1), C28.1, HE14.2 (OUT)
HE15: AM3.1 (X4), C30.1, HE15.2 (OUT)
HE16: AM3.2 (X6), C32.1, HE16.2 (OUT)
HE17: AM3.4 (X7), C34.1, HE17.2 (OUT)
HE18: AM3.5 (X5), C36.1, HE18.2 (OUT)
HE19: AM3.15 (X2), C38.1, HE19.2 (OUT)
HE20: AM3.14 (X1), C40.1, HE20.2 (OUT)
HE21: AM3.13 (X0), C42.1, HE21.2 (OUT)
HE22: AM3.12 (X3), C44.1, HE22.2 (OUT)
HE23: AM4.1 (X4), C46.1, HE23.2 (OUT)
HE24: AM4.2 (X6), C48.1, HE24.2 (OUT)
HE25: AM4.4 (X7), C50.1, HE25.2 (OUT)
HE26: AM4.5 (X5), C52.1, HE26.2 (OUT)
HE27: AM4.15 (X2), C54.1, HE27.2 (OUT)
HE28: AM2.12 (X3), C56.1, HE28.2 (OUT)
HE29: AM2.13 (X0), C58.1, HE29.2 (OUT)
HE30: AM5.1 (X4), C60.1, HE30.2 (OUT)
HE31: AM5.2 (X6), C62.1, HE31.2 (OUT)
HE32: AM5.4 (X7), C64.1, HE32.2 (OUT)
HE33: AM5.5 (X5), C66.1, HE33.2 (OUT)
HE34: AM5.15 (X2), C68.1, HE34.2 (OUT)
HE35: AM5.14 (X1), C70.1, HE35.2 (OUT)
HE36: AM5.13 (X0), C72.1, HE36.2 (OUT)
HE37: AM5.12 (X3), C74.1, HE37.2 (OUT)
HE38: AM6.1 (X4), C76.1, HE38.2 (OUT)
HE39: AM6.2 (X6), C78.1, HE39.2 (OUT)
HE40: AM6.4 (X7), C80.1, HE40.2 (OUT)
HE41: AM4.14 (X1), C82.1, HE41.2 (OUT)
HE42: AM4.13 (X0), C84.1, HE42.2 (OUT)
HE43: AM4.12 (X3), C86.1, HE43.2 (OUT)
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
Notes on the sheet:
AM9
AM6
AM12
AM7
AM14
AM8
AM1
AM15
AM3
AM2
AM11
AM5
AM10
AM13
AM4
Switches

Board: 2 copper layers, 447.0 x 162.8 mm, 518 parts (334 on the bottom side), 161 nets.

Other parts of the board:
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H19, H20, H21, H22, H23, H24, H25, H26, H27, H28, H29, H30, H31, H32, H33, H34, H35, H36, H37, H38, H39, H40, H41, H42, H43, H44, H45, H46, H47, H48, H49, H50, H51, H52, H53, H54, H55, H56, H57, H58: MountingHole; MountingHole_3mm

## Code that names these connections

File keyboard_keyboard/code/src/main.rs (part):

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    // ── 1 kHz scan loop ───────────────────────────────────────────────────────
    #[task(
        binds = TIM2,
        local  = [timer2, adc, adc_pins, enb_a, enb_b, enb_c, adc_pin_a9, adc_pin_a10,
                  adc_pin_a11, pot_last_cc, s0, s1, s2, mux_raw, filters, velocity_filters, dynamic_baselines,
                  last_pitch_bend, last_vibrato_cc, led1, led2, led3, midi_rx,
                  led1_off_at, led2_off_at,
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